Commit message: minor changes

File: src/robot_core/src/robot_core/model/robot_core.xacro (robot description, xacro)
@@ -15,4 +15,7 @@
   <material name="black">
     <color rgba="0 0 0 1"/>
+  </material>
+  <material name="red">
+    <color rgba="1 0 0 1"/>
   </material>
   <!-- BASE -->
